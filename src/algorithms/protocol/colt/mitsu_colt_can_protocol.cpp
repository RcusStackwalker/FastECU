#include "src/algorithms/protocol/colt/mitsu_colt_can_protocol.h"

#include <cassert>

#include "src/algorithms/protocol/bytes_compose.h"
#include "src/algorithms/protocol/uds/uds_pdu.h"
#include <array>

namespace mitsu_colt_can
{
using bytes::ComposeBe;
using bytes::U24;
using namespace bytes::literals;

const std::array<bytes::Byte, kEraseRoutineSize> kErasePageRoutine = {
    0x94, 0xf0, 0x20, 0x20, 0x24, 0x20, 0xf0, 0x00, 0xe4, 0x00, 0xd0, 0xd0, 0x24, 0x20, 0x64, 0x32, 0x44, 0xff,
    0xf0, 0x00, 0xb0, 0x94, 0xff, 0xff, 0xd8, 0xc0, 0x01, 0x6e, 0x88, 0xe8, 0x36, 0x00, 0xe1, 0x80, 0x56, 0x54,
    0x1e, 0xc1, 0xf0, 0x00, 0xe1, 0x80, 0x07, 0xe1, 0x21, 0x91, 0xf0, 0x00, 0x81, 0xc1, 0x00, 0x01, 0xb0, 0x91,
    0x00, 0x18, 0x48, 0xff, 0xf0, 0x00, 0xb0, 0x98, 0xff, 0xf9, 0xe2, 0xff, 0xff, 0xff, 0xe2, 0xff, 0xff, 0xff,
    0xe2, 0xff, 0xff, 0xff, 0xe2, 0xff, 0xff, 0xff, 0xe2, 0xff, 0xff, 0xef, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x60, 0x01, 0xf0, 0x00, 0xb0, 0x98, 0x00, 0x02, 0x60, 0x00, 0xf0, 0x00,
};

const std::array<bytes::Byte, 176> kWritePageRoutine = {
    0x94, 0xf0, 0x41, 0x41, 0x24, 0x20, 0xf0, 0x00, 0x85, 0xa0, 0x01, 0x00, 0x24, 0xb1, 0x24, 0x20, 0x40, 0x02,
    0x41, 0x02, 0xb0, 0x15, 0xff, 0xfe, 0xe5, 0xff, 0xff, 0xff, 0xe5, 0xff, 0xff, 0xff, 0xe5, 0xff, 0xff, 0xff,
    0xe5, 0xff, 0xff, 0xff, 0xe5, 0xff, 0xff, 0xff, 0xe5, 0xff, 0xff, 0xff, 0xe5, 0xff, 0x00, 0x34, 0xe5, 0xff,
    0xff, 0xff, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xd8, 0xc0,
    0x01, 0x6e, 0x88, 0xe8, 0x36, 0x00, 0xe1, 0x80, 0x56, 0x54, 0x1e, 0xc1, 0xf0, 0x00, 0xe1, 0x80, 0x07, 0xe1,
    0x21, 0x91, 0xf0, 0x00, 0x81, 0xc1, 0x00, 0x01, 0xb0, 0x91, 0x00, 0x03, 0x48, 0xff, 0xf0, 0x00, 0xb0, 0x98,
    0xff, 0xf9, 0x60, 0x01, 0xf0, 0x00, 0xb0, 0x98, 0x00, 0x02, 0x60, 0x00, 0xf0, 0x00,
};

const std::array<bytes::Byte, kEraseRoutineSize> kEraseRedirectRoutine = {
    0xD3, 0xC0, 0x00, 0x02, 0x83, 0xE3, 0x80, 0x00, 0x00, 0x53, 0x7D, 0x15, 0xD2, 0xC0, 0x00, 0x05, 0x82, 0xE2,
    0x80, 0x00, 0x00, 0xA2, 0xF0, 0x00, 0x94, 0xF0, 0x20, 0x20, 0x24, 0x20, 0xF0, 0x00, 0xE4, 0x00, 0xD0, 0xD0,
    0x24, 0x20, 0x64, 0x32, 0x44, 0xFF, 0xF0, 0x00, 0xB0, 0x94, 0xFF, 0xFF, 0xD8, 0xC0, 0x01, 0x6E, 0x88, 0xE8,
    0x36, 0x00, 0xE1, 0x80, 0x56, 0x54, 0x1E, 0xC1, 0xF0, 0x00, 0xE1, 0x80, 0x07, 0xE1, 0x21, 0x91, 0xF0, 0x00,
    0x81, 0xC1, 0x00, 0x01, 0xB0, 0x91, 0x00, 0x12, 0x48, 0xFF, 0xF0, 0x00, 0xB0, 0x98, 0xFF, 0xF9, 0x7F, 0x0F,
    0xF0, 0x00, 0x68, 0x01, 0x7F, 0x0E, 0xE2, 0xFF, 0xFF, 0xFF, 0xE2, 0xFF, 0xFF, 0xFF, 0xE2, 0xFF, 0xFF, 0xFF,
    0xE2, 0xFF, 0xFF, 0xFF, 0xE2, 0xFF, 0xFF, 0xFF, 0xE2, 0xFF, 0xFF, 0xFF, 0xE2, 0xFF, 0xFF, 0xFF, 0xE2, 0x00,
    0x00, 0x88, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xF0, 0x00, 0xB0, 0x98, 0x00, 0x02, 0x60, 0x00, 0xF0, 0x00};

const std::array<bytes::Byte, kWriteRoutineSize> kWriteRedirectRoutine = {
    0xD2, 0xC0, 0x00, 0x05, 0x82, 0xE2, 0x80, 0x00, 0x00, 0xA2, 0xF0, 0x00, 0x94, 0xF0, 0x41, 0x41, 0x24, 0x20,
    0xF0, 0x00, 0x85, 0xA0, 0x01, 0x00, 0x24, 0xB1, 0x24, 0x20, 0x40, 0x02, 0x41, 0x02, 0xB0, 0x15, 0xFF, 0xFE,
    0xE5, 0xFF, 0xFF, 0xFF, 0xE5, 0xFF, 0xFF, 0xFF, 0xE5, 0xFF, 0xFF, 0xFF, 0xE5, 0xFF, 0xFF, 0xFF, 0xE5, 0xFF,
    0xFF, 0xFF, 0xE5, 0xFF, 0xFF, 0xFF, 0xE5, 0xFF, 0x00, 0x34, 0xE5, 0xFF, 0xFF, 0xFF, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
    0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xD8, 0xC0,
    0x01, 0x6E, 0x88, 0xE8, 0x36, 0x00, 0xE1, 0x80, 0x56, 0x54, 0x1E, 0xC1, 0xF0, 0x00, 0xE1, 0x80, 0x07, 0xE1,
    0x21, 0x91, 0xF0, 0x00, 0x81, 0xC1, 0x00, 0x01, 0xB0, 0x91, 0x00, 0x03, 0x48, 0xFF, 0xF0, 0x00, 0xB0, 0x98,
    0xFF, 0xF9, 0x60, 0x01, 0xF0, 0x00, 0xB0, 0x98, 0x00, 0x02, 0x60, 0x00, 0xF0, 0x00};

std::uint16_t SeedKeyWord(std::uint16_t seed_word)
{
    return static_cast<std::uint16_t>(std::uint32_t(seed_word) * 135 + 1542);
}

bytes::Bytes SeedKey(bytes::ByteView seed)
{
    assert(seed.size() == 4);
    const std::uint16_t pk1 = bytes::ReadU16Be(seed, 0);
    const std::uint16_t pk2 = bytes::ReadU16Be(seed, 2);
    const std::uint16_t sk1 = SeedKeyWord(pk1);
    const std::uint16_t sk2 = SeedKeyWord(pk2);
    return ComposeBe(sk1, sk2);
}

std::uint16_t Checksum(bytes::ByteView data)
{
    std::uint16_t sum = 0;
    for (bytes::Byte byte : data)
    {
        sum += byte;
    }
    return sum;
}

bool IsDestructiveRequest(bytes::ByteView pdu)
{
    if (pdu.empty())
    {
        return false;
    }
    if (pdu[0] == kServiceRequestReflash || pdu[0] == kServiceRequestDownload || pdu[0] == kServiceTransferData)
    {
        return true;
    }
    return pdu.size() >= 2 && pdu[0] == kServiceRoutineControl && pdu[1] == kRoutineErase;
}

bytes::Bytes BuildRequestDownload(std::uint32_t start, std::uint32_t size)
{
    return uds::BuildRequest(kServiceRequestDownload, ComposeBe(U24(start), 0x00_b, U24(size)));
}

std::vector<bytes::Bytes> BuildTransferDataFrames(bytes::ByteView payload)
{
    std::vector<bytes::Bytes> frames;
    for (std::size_t offset = 0; offset < payload.size(); offset += kTransferChunkSize)
    {
        const std::size_t chunk_size = std::min<std::size_t>(kTransferChunkSize, payload.size() - offset);
        frames.push_back(uds::BuildRequest(kServiceTransferData, payload.subspan(offset, chunk_size)));
    }
    return frames;
}

bytes::Bytes BuildRoutineCheckCrc(std::uint32_t target_start)
{
    return uds::BuildRequest(kServiceRoutineControl, kRoutineCheckCrc, ComposeBe(target_start < 0x800000 ? 2_b : 1_b));
}

bytes::Bytes BuildRoutineErase()
{
    return uds::BuildRequest(kServiceRoutineControl, kRoutineErase);
}

bytes::Bytes BuildRequestReflashUnlock()
{
    // The SID moved into uds::buildRequest below; the remaining 11 bytes are
    // the tail of the 12-byte literal in
    // externals/livemonitor/obdsessionwidget.cpp:180-181, verbatim, and the
    // frame this builds is still that literal byte for byte. Original author's
    // comment: "caused bootloader lockup". See header doc.
    static constexpr std::array<bytes::Byte, 11> kData{154, 1, 1, 'R', 'c', 'u', 's', '0', '0', 0, 1};
    return uds::BuildRequest(kServiceRequestReflash, bytes::ByteView(kData));
}

bytes::Bytes BuildReadMemoryByAddress(std::uint32_t addr, bytes::Byte len)
{
    return uds::BuildRequest(kServiceReadMemoryByAddress, ComposeBe(U24(addr), len));
}

bytes::Bytes BuildDiagnosticSession(bytes::Byte session_id)
{
    return uds::BuildRequest(kServiceDiagnosticSession, session_id);
}

bytes::Bytes BuildSecurityAccessSeedRequest()
{
    return uds::BuildRequest(kServiceSecurityAccess, 0x05_b);
}

bytes::Bytes BuildSecurityAccessKey(bytes::ByteView key)
{
    assert(key.size() == 4);
    return uds::BuildRequest(kServiceSecurityAccess, 0x06_b, key);
}

} // namespace mitsu_colt_can
